# Keil uVision project ex2.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ex2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: ex2.cpp Lab_2_ex2.cpp
software components: CMSIS:CORE 6.0.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
