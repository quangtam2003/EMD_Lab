# Keil uVision project Lab04.Task3.uvprojx, settings and files
target LPC1768_Lab02 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: Lab02_StudentName_StudentID
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: Joystick.c Led.c main.c Uart.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Graphic LCD 1.0.0, Board Support:Joystick 1.0.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
